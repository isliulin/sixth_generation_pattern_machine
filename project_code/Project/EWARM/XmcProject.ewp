# IAR project XmcProject.ewp, settings and files
configuration XMC4500 (ARM, debug)
  General.OGChipSelectEditMenu: XMC4500-F144x1024 Infineon XMC4500-F144x1024
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: XMC4500_F100x1024
  ICCARM.CCIncludePath2: ..\..\Libraries\XMCLib\inc; ..\..\Libraries\CMSIS\Include; ..\..\Libraries\CMSIS\Device\Infineon\XMC4500_series\Include; ..\..\Applications\App\inc; ..\..\Applications\Bsp\inc; ..\..\Applications\Motor\inc; ..\..\Applications\System\inc; ..\..\Applications\Unit\inc; ..\..\Applications\User\inc; ..\..\Applications\Test
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: XmcProject.bin
  ILINK.IlinkOutputFile: XmcProject.out
  ILINK.IlinkIcfFile: XMC4500xxxxx1024.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: XMC4402-F100x256 Infineon XMC4402-F100x256
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: XMC4402_F100x256
  ICCARM.CCIncludePath2: ..\..\Libraries\XMCLib\inc; ..\..\Libraries\CMSIS\Include; ..\..\Libraries\CMSIS\Device\Infineon\XMC4400_series\Include; ..\..\Applications\App\inc; ..\..\Applications\Bsp\inc; ..\..\Applications\Motor\inc; ..\..\Applications\System\inc; ..\..\Applications\Unit\inc; ..\..\Applications\User\inc; ..\..\Applications\Test
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkIcfFile: XMC4402xxxxx256.icf
configuration Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: XMC4402-F100x256 Infineon XMC4402-F100x256
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: XMC4402_F100x256
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptStrategy: 0
  ILINK.IlinkIcfFile: XMC4402xxxxx256.icf
  group Applications/App
    ../../Applications/App/src/: app_adc.c app_boot.c app_can.c app_config.c app_dac.c app_debug.c app_delay.c app_eeprom.c app_flash.c app_gpio.c app_hardware.c app_key.c app_led.c app_pwm.c app_rs485.c app_software.c app_spi.c app_test.c app_uart.c
    ../../Applications/App/inc/: app_adc.h app_boot.h app_can.h app_config.h app_dac.h app_debug.h app_delay.h app_eeprom.h app_flash.h app_gpio.h app_hardware.h app_key.h app_led.h app_pwm.h app_rs485.h app_software.h app_spi.h app_test.h app_uart.h
  group Applications/Bsp
    ../../Applications/Bsp/src/: bsp_adc.c bsp_can.c bsp_config.c bsp_dac.c bsp_debug.c bsp_flash.c bsp_gpio.c bsp_iic.c bsp_pwm.c bsp_rs485.c bsp_spibus.c bsp_spiflash.c bsp_uart.c
    ../../Applications/Bsp/inc/: bsp_adc.h bsp_can.h bsp_config.h bsp_dac.h bsp_debug.h bsp_flash.h bsp_gpio.h bsp_iic.h bsp_pwm.h bsp_rs485.h bsp_spibus.h bsp_spiflash.h bsp_uart.h
  group Applications/Motor
    ../../Applications/Motor/src/: mc_config.c mc_control.c mc_curve.c mc_driver.c
    ../../Applications/Motor/inc/: mc_config.h mc_control.h mc_curve.h mc_driver.h
  group Applications/System
    ../../Applications/System/src/: sys_config.c sys_variable.c
    ../../Applications/System/inc/: sys_config.h sys_variable.h
  group Applications/Test
    ../../Applications/Test/: CAN0.c CAN0.h CAN1.c CAN1.h CCU40.c CCU40.h CCU41.c CCU41.h CCU42.c CCU42.h CCU43.c CCU43.h CCU80.c CCU80.h CCU81.c CCU81.h POSIF0.c POSIF0.h POSIF1.c POSIF1.h U0C0.c U0C0.h U0C1.c U0C1.h U1C0.c U1C0.h U1C1.c U1C1.h
  group Applications/Unit
    ../../Applications/Unit/src/: IQmathLib.a unit_crc.c unit_lrc.c
    ../../Applications/Unit/inc/: IQmathLib.h unit_crc.h unit_lrc.h
  group Applications/User
    ../../Applications/User/inc/: includes.h IRQHandler.h main.h
    ../../Applications/User/src/: IRQHandler.c main.c
  group Documents
    ../../Documents/: readme.txt
  group Libraries/CMSIS/Device/Infineon/XMC4400_series
    ../../Libraries/CMSIS/Device/Infineon/XMC4400_series/Source/IAR/: startup_XMC4402.s
    ../../Libraries/CMSIS/Device/Infineon/XMC4400_series/Source/: system_XMC4400.c
  group Libraries/CMSIS/Device/Infineon/XMC4500_series
    ../../Libraries/CMSIS/Device/Infineon/XMC4500_series/Source/IAR/: startup_XMC4500.s
    ../../Libraries/CMSIS/Device/Infineon/XMC4500_series/Source/: system_XMC4500.c
  group Libraries/XMClib/inc
    ../../Libraries/XMCLib/inc/: xmc4_ccu4_map.h xmc4_ccu8_map.h xmc4_eru_map.h xmc4_flash.h xmc4_gpio.h xmc4_gpio_map.h xmc4_rtc.h xmc4_scu.h xmc4_usic_map.h xmc_acmp.h xmc_bccu.h xmc_can.h xmc_can_map.h xmc_ccu4.h xmc_ccu8.h xmc_common.h xmc_dac.h xmc_device.h xmc_dma.h xmc_dma_map.h xmc_dsd.h xmc_ebu.h xmc_ecat.h xmc_ecat_map.h xmc_eru.h xmc_eth_mac.h xmc_eth_mac_map.h xmc_eth_phy.h xmc_fce.h xmc_flash.h xmc_gpio.h xmc_hrpwm.h xmc_hrpwm_map.h xmc_i2c.h xmc_i2s.h xmc_ledts.h xmc_math.h xmc_pau.h xmc_posif.h xmc_posif_map.h xmc_prng.h xmc_rtc.h xmc_scu.h xmc_sdmmc.h xmc_spi.h xmc_uart.h xmc_usbd.h xmc_usbd_regs.h xmc_usbh.h xmc_usic.h xmc_vadc.h xmc_vadc_map.h xmc_wdt.h
  group Libraries/XMClib/src
    ../../Libraries/XMCLib/src/: xmc4_eru.c xmc4_flash.c xmc4_gpio.c xmc4_rtc.c xmc4_scu.c xmc_acmp.c xmc_bccu.c xmc_can.c xmc_ccu4.c xmc_ccu8.c xmc_common.c xmc_dac.c xmc_dma.c xmc_dsd.c xmc_ebu.c xmc_eru.c xmc_fce.c xmc_gpio.c xmc_hrpwm.c xmc_math.c xmc_pau.c xmc_posif.c xmc_prng.c xmc_rtc.c xmc_spi.c xmc_uart.c xmc_usic.c xmc_vadc.c xmc_wdt.c

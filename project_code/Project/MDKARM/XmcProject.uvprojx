# Keil uVision project XmcProject.uvprojx, settings and files
target XMC4500 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: XMC4500-F100x1024 Infineon
  pack: Infineon.XMC4000_DFP.2.10.0
  cpu: IRAM(0x20000000,0xFFC0) IRAM2(0x10000000,0x10000) IROM(0x08000000,0x100000) IROM2(0x0C000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: XmcProject +hex
  AfterMake: fromelf --bin --output "$L@L.bin"  "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: XMC4500_F100x1024
  c include: ..\..\Libraries\XMCLib\inc;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\Infineon\XMC4500_series\Include;..\..\Applications\App\inc;..\..\Applications\Bsp\inc;..\..\Applications\System\inc;..\..\Applications\Unit\inc;..\..\Applications\User\inc;..\..\Applications\Motor\inc;..\..\Applications\Test
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0xc000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0xffc0
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Applications/App
    ../../Applications/App/src/: app_can.c app_dac.c app_delay.c app_eeprom.c app_gpio.c app_pwm.c app_uart.c app_flash.c app_spiflash.c app_Init.c
  group Applications/Bsp
    ../../Applications/Bsp/src/: bsp_can.c bsp_dac.c bsp_flash.c bsp_gpio.c bsp_iic.c bsp_pwm.c bsp_rs485.c bsp_uart.c bsp_spibus.c bsp_spiflash.c bsp_scu.c bsp_delay.c bsp_watch.c
    ../../Applications/Bsp/SPI_MASTER/: spi_master.c spi_master_conf.c
    ../../Applications/Bsp/CAN_NODE/: can_node.c can_node_conf.c
    ../../Applications/Bsp/GLOBAL_CAN/: global_can.c global_can_conf.c
  group Applications/Motor
    ../../Applications/Motor/: motor_drive.h motor_drive.lib
  group Applications/System
    ../../Applications/System/src/: sys_variable.c watch.c
  group Applications/Unit
    ../../Applications/Unit/src/: IQmathLib.lib unit_crc.c unit_lrc.c
  group Applications/User
    ../../Applications/User/inc/: includes.h main.h communication.h typedef.h action.h step_motor_drv.h parameter.h io_file_struct.h
    ../../Applications/User/src/: main.c action.c communication.c delay.c initial.c parameter.c step_motor_drv.c system.c io_function.c io_file_struct.c stepper_function.c debug.c rc522_codebar.c nopmove_speed.c
    ../../Applications/System/inc/: sys_variable.h
  group Libraries/CMSIS
    ./RTE/_Debug/: startup_XMC4402.s system_XMC4400.c
  group Libraries/XMClib/src
    ../../Libraries/XMCLib/src/: xmc_acmp.c xmc_bccu.c xmc_can.c xmc_ccu4.c xmc_ccu8.c xmc_common.c xmc_dac.c xmc_dma.c xmc_dsd.c xmc_ebu.c xmc_eru.c xmc_spi.c xmc_fce.c xmc_gpio.c xmc_math.c xmc_pau.c xmc_posif.c xmc_prng.c xmc_rtc.c xmc_uart.c xmc_usic.c xmc_vadc.c xmc_wdt.c xmc4_eru.c xmc4_flash.c xmc4_gpio.c xmc4_rtc.c xmc4_scu.c
  group Libraries/XMClib/inc
    ../../Libraries/XMCLib/inc/: xmc_acmp.h xmc_bccu.h xmc_can.h xmc_can_map.h xmc_ccu4.h xmc_ccu8.h xmc_common.h xmc_dac.h xmc_device.h xmc_dma.h xmc_dma_map.h xmc_dsd.h xmc_ebu.h xmc_eru.h xmc_fce.h xmc_flash.h xmc_gpio.h xmc_hrpwm.h xmc_hrpwm_map.h xmc_math.h xmc_pau.h xmc_posif.h xmc_posif_map.h xmc_prng.h xmc_rtc.h xmc_scu.h xmc_spi.h xmc_uart.h xmc_usic.h xmc_vadc.h xmc_vadc_map.h xmc_wdt.h xmc4_ccu4_map.h xmc4_ccu8_map.h xmc4_eru_map.h xmc4_flash.h xmc4_gpio.h xmc4_gpio_map.h xmc4_rtc.h xmc4_scu.h xmc4_usic_map.h
target Debug (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: XMC4402-F100x256 Infineon
  pack: Infineon.XMC4000_DFP.2.10.0
  cpu: IRAM(0x20000000,0xFFC0) IRAM2(0x1FFFC000,0x4000) IROM(0x08000000,0x40000) IROM2(0x0C000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: XmcProject +hex
  AfterMake: fromelf --bin --output "$L@L.bin"  "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: XMC4402_F100x256
  c include: ..\..\Libraries\XMCLib\inc;..\..\Libraries\CMSIS\Include;..\..\Libraries\CMSIS\Device\Infineon\XMC4500_series\Include;..\..\Applications\App\inc;..\..\Applications\Bsp\inc;..\..\Applications\System\inc;..\..\Applications\Unit\inc;..\..\Applications\User\inc;..\..\Applications\Bsp\CAN_NODE;..\..\Applications\Bsp\GLOBAL_CAN;..\..\Applications\Motor
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT5: ROM 0xc000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xffc0
  memory RVCT10: RAM 0x1fffc000 size 0x4000
target Release (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: XMC4500-F100x1024 Infineon
  pack: Infineon.XMC4000_DFP.2.10.0
  cpu: as above
  output: XmcProject +hex
  AfterMake: fromelf --bin --output "$L@L.bin"  "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: XMC4500_F100x1024
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0xc000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0xffc0
  memory RVCT10: RAM 0x10000000 size 0x10000
software components: CMSIS:DSP 1.5.2
